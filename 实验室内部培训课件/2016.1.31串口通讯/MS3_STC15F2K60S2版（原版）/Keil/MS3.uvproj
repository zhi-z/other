# Keil uVision project MS3.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MS3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../SourceFile/: app.c mmi.c system.c device_key.c device_rtc.c device_timer.c device_usart.c device_sensor.c device_systick.c
